IMAGE_INSTALL_append = " supportDocs"
