IMAGE_INSTALL_append = " executable"
