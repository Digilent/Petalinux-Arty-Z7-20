SRC_URI += "file://user_2017-07-10-08-35-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

